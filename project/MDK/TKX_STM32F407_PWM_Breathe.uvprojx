# Keil uVision project TKX_STM32F407_PWM_Breathe.uvprojx, settings and files
target TKX_STM32F407_PWM_Breathe (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: TKX_STM32F407_PWM_Breathe +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx,HSE_VALUE=8000000,USER_VECT_TAB_ADDRESS
  c misc: -std=c99
  c include: ..\..\board;..\..\libraries\CMSIS\Core\Include;..\..\libraries\STM32F4\Include
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../../app/: main.c
  group Board
    ../../board/: board.c
  group STARTUP
    ../../libraries/STM32F4/Source/: startup_stm32f407xx.s
  group CMSIS
    ../../libraries/STM32F4/Source/: system_stm32f4xx.c
